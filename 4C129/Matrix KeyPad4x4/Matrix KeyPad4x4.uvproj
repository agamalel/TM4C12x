# Keil uVision project Matrix KeyPad4x4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Matrix KeyPad4x4
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup.s SSI_Nokia5110.c SSI_Nokia5110.h tm4c123gh6pm.h PLL.c PLL.h Matrix KeyPad4x4.c
