# Keil uVision project PWM & Edge Trigger Interrupts.uvproj, settings and files
target PWM & Edge Trigger Interrupts (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: PWM & Edge Trigger Interrupts
  c flags: Optim=1 OneElfS=1
  c define: rvmdk PART_LM4F120H5QR
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main Prog
    ./: Phan Control.c
  group Startup
    ./: startup.s
  group Phase Locked Loop
    ./: PLL.c
  group SysTick Timer
    ./: SysTick.c
  group UART
    ./: UART0.c
  group Timer0PWM
    ./: Timer0PWM.c
