# Keil uVision project PC Controls uC over UART.uvproj, settings and files
target PC Controls uC over UART (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: PC Controls uC over UART
  c flags: Optim=1 OneElfS=1
  c define: rvmdk PART_LM4F120H5QR
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main Prog
    ./: main.c PLL.c
  group Startup
    ./: startup.s
  group UART0
    ./: UART0.c UART0.h
