# Keil uVision project TemperatureSensor.uvproj, settings and files
target Internal Temperature Sensor (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: TemperatureSensor
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group TestMain
    ./: main.c
  group TemperatureSensor
    ./: TemperatureSensor.c
  group PLL
    ./: PLL.c
  group Nokia5110
    ./: SSI_Nokia5110.c
  group startup
    ./: startup.s
