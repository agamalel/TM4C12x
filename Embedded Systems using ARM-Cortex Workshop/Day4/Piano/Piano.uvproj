# Keil uVision project Piano.uvproj, settings and files
target main (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: 4-bit Piano
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group TestMain
    ./: main.c
  group Piano
    ./: Piano.c
  group DAC
    ./: DAC.c
  group PLL
    ./: PLL.c
  group Startup
    ./: startup.s
  group Sound
    ./: Sound.c
